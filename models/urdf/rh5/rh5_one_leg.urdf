Commit message: Update test cases and examples

File: models/urdf/rh5/rh5_one_leg.urdf (robot description, URDF)
Before this commit: robot RH5, 14 links, 13 joints
Joints:
- joint LLHip1: origin xyz=0.0 0.0 0.0 rpy=8.0247e-16 0.2618 -1.5708 -> xyz=-0.11044 0.0735 0.01427 rpy=0 0.2618 0
